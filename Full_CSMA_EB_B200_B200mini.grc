<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Extranjero</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>access_code</value></param>
<param><key>value</key><value>gwnutils.default_access_code</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e5</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>analog_probe_avg_mag_sqrd_x_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>threshold</key><value>-140</value></param>
<param><key>type</key><value>c</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/gnuradio/capa física Belza/output.dat</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>50007</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_1_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>50008</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>correlate</value></param>
</block>
<block>
<key>digital_correlate_access_code_xx_ts</key>
<param><key>id</key><value>digital_correlate_access_code_xx_ts_0</value></param>
<param><key>access_code</key><value>access_code</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>correlate</value></param>
<param><key>threshold</key><value>1</value></param>
</block>
<block>
<key>gwn_CSMA_FSM</key>
<param><key>id</key><value>gwn_CSMA_FSM_0</value></param>
<param><key>ack_nickname</key><value>'CtrlACK'</value></param>
<param><key>block_id</key><value>analog_probe_avg_mag_sqrd_x_0</value></param>
<param><key>buffer_len</key><value>1000</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>fsm_debug</key><value>False</value></param>
<param><key>function_args</key><value></value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>max_retries</key><value>1000</value></param>
<param><key>tout_backoff</key><value>'TimerTOH'</value></param>
<param><key>timeout_backoff</key><value>0.1</value></param>
<param><key>tout_nickname</key><value>'EventTimer'</value></param>
<param><key>timeout</key><value>0.5</value></param>
<param><key>transmit_threshold</key><value>1.0</value></param>
</block>
<block>
<key>gwn_ack_rx</key>
<param><key>id</key><value>gwn_ack_rx_0</value></param>
<param><key>ack_nickname</key><value>'CtrlACK'</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>gwn_ev_to_pdu</key>
<param><key>id</key><value>gwn_ev_to_pdu_0</value></param>
<param><key>in_type</key><value>'payload'</value></param>
</block>
<block>
<key>gwn_event_constructor</key>
<param><key>id</key><value>gwn_event_constructor_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>dst_address</key><value>'Metalico'</value></param>
<param><key>Destination</key><value>False</value></param>
<param><key>seq_nr</key><value>1</value></param>
<param><key>src_address</key><value>'EstacionBase'</value></param>
</block>
<block>
<key>gwn_event_guider</key>
<param><key>id</key><value>gwn_event_guider_0</value></param>
<param><key>type_2</key><value>'CtrlACK'</value></param>
<param><key>Broadcast</key><value>False</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>type_1</key><value>'DataData'</value></param>
<param><key>my_address</key><value>'EstacionBase'</value></param>
</block>
<block>
<key>gwn_hier_rx_psk</key>
<param><key>id</key><value>gwn_hier_rx_psk_0</value></param>
<param><key>agc_attack_rate</key><value>0.6</value></param>
<param><key>agc_decay_rate</key><value>0.6</value></param>
<param><key>agc_gain</key><value>15.0</value></param>
<param><key>agc_reference</key><value>2.0</value></param>
<param><key>constellation</key><value>digital.constellation_calcdist([-1-1j, 1-1j, 1+1j, -1+1j], [], 4, 1).base()</value></param>
<param><key>alpha_probe</key><value>0.1</value></param>
<param><key>bits_per_sym</key><value> 2 </value></param>
<param><key>bw_clock_sync</key><value> 2*3.14/100 </value></param>
<param><key>bw_costas</key><value> 2*3.14/100 </value></param>
<param><key>bw_fll</key><value> 3.14/1600 </value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>len_sym_srrc</key><value> 7 </value></param>
<param><key>n_filts</key><value> 32 </value></param>
<param><key>samp_per_sym</key><value>3</value></param>
<param><key>th_probe</key><value>0</value></param>
</block>
<block>
<key>gwn_hier_tx_psk</key>
<param><key>id</key><value>gwn_hier_tx_psk_0</value></param>
<param><key>constellation</key><value>[-1-1j, 1-1j, 1+1j, -1+1j]</value></param>
<param><key>bits_per_sym</key><value> 2 </value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>len_sym_srrc</key><value> 7 </value></param>
<param><key>out_const_mul</key><value> 0.4 </value></param>
<param><key>samp_per_sym</key><value>3</value></param>
</block>
<block>
<key>gwn_l1_deframer</key>
<param><key>id</key><value>gwn_l1_deframer_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>out_type</key><value>'event'</value></param>
</block>
<block>
<key>gwn_l1_framer</key>
<param><key>id</key><value>gwn_l1_framer_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>in_type</key><value>'event'</value></param>
</block>
<block>
<key>gwn_pdu_to_ev</key>
<param><key>id</key><value>gwn_pdu_to_ev_0</value></param>
<param><key>in_type</key><value>'payload'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio import digital</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import gwnutils</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>400000000.0</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>400000000.0</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>60</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>gwn_hier_tx_psk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_1_0</source_block_id><sink_block_id>gwn_pdu_to_ev_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>gwn_l1_deframer_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_xx_ts_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gwn_CSMA_FSM_0</source_block_id><sink_block_id>gwn_l1_framer_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_CSMA_FSM_0</source_block_id><sink_block_id>gwn_ev_to_pdu_0</sink_block_id><source_key>out1</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_ack_rx_0</source_block_id><sink_block_id>gwn_ev_to_pdu_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_ack_rx_0</source_block_id><sink_block_id>gwn_l1_framer_0</sink_block_id><source_key>out1</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_ev_to_pdu_0</source_block_id><sink_block_id>blocks_socket_pdu_1</sink_block_id><source_key>pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gwn_event_constructor_0</source_block_id><sink_block_id>gwn_CSMA_FSM_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_event_guider_0</source_block_id><sink_block_id>gwn_ack_rx_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_event_guider_0</source_block_id><sink_block_id>gwn_CSMA_FSM_0</sink_block_id><source_key>out1</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_hier_rx_psk_0</source_block_id><sink_block_id>digital_correlate_access_code_xx_ts_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gwn_hier_tx_psk_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gwn_l1_deframer_0</source_block_id><sink_block_id>gwn_event_guider_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>gwn_l1_framer_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdu</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>gwn_pdu_to_ev_0</source_block_id><sink_block_id>gwn_event_constructor_0</sink_block_id><source_key>out0</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_probe_avg_mag_sqrd_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>gwn_hier_rx_psk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
